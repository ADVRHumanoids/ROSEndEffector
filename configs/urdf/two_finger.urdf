Commit message: now time margins of actionTimeds are considered

File: configs/urdf/two_finger.urdf (robot description, URDF)
Before this commit: robot two_finger_end_effector, 6 links, 5 joints
Links:
- added link world
Joints:
- added joint virtualFixed: type fixed, parent world, child motor
