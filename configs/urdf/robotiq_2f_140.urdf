Commit message: robotiq 2f prepared for gazebo

File: configs/urdf/robotiq_2f_140.urdf (robot description, URDF)
Before this commit: robot robotiq_2f_140, 11 links, 10 joints
Links:
- added link world
Joints:
- added joint virtualFixed: type fixed, parent world, child robotiq_arg2f_base_link
