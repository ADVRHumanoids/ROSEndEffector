Commit message: robotiq fixed conf files

File: configs/urdf/robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot robotiq_2f_85, 12 links, 11 joints
Joints:
- joint finger_joint: limit lower=0 upper=0.8 effort=1000 velocity=2.0 -> lower=0 upper=0.82 effort=1000 velocity=2.0
